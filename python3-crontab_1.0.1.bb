SUMMARY = "Parse and use crontab schedules in Python"

HOMEPAGE = "https://github.com/josiahcarlson/parse-crontab"

LICENSE = "LGPL-2.0-or-later"

LIC_FILES_CHKSUM = "file://LICENSE;md5=23c2a5e0106b99d75238986559bb5fc6"

SRC_URI[sha256sum] = "89477e3f93c81365e738d5ee2659509e6373bb2846de13922663e79aa74c6b91"

inherit pypi setuptools3

